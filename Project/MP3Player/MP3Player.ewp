# IAR project MP3Player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; DEBUG; BUFSIZE=256; SONGLEN=32
  ICCARM.CCDiagSuppress: Pe2464, Ms014
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341; Arduino\SD\src; App; App\Tasks; Bitmaps; GUI
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MP3Player.sim
  ILINK.IlinkOutputFile: MP3Player.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; NDEBUG; BUFSIZE=256; SONGLEN=32
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341; Arduino\SD\src; Arduino\SD\src\utility; GUI; App
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: MP3Player.srec
  group Adafruit/Adafruit-GFX
    Adafruit/Adafruit-GFX/: Adafruit_GFX.cpp Adafruit_GFX.h glcdfont.c library.properties license.txt README.txt
  group Adafruit/Adafruit_FT6206
    Adafruit/Adafruit_FT6206/: Adafruit_FT6206.cpp Adafruit_FT6206.h library.properties README.txt
  group Adafruit/Adafruit_ILI9341
    Adafruit/Adafruit_ILI9341/: Adafruit_ILI9341.cpp Adafruit_ILI9341.h library.properties README.txt
  group App
    App/: LinkedList.h main.c mp3Util.c mp3Util.h shell.c
  group App/Tasks
    App/Tasks/: commandHandler.c lcdHandler.c streaming.c tasks.c tasks.h touchPolling.c
  group App/uCOS
    App/uCOS/: app_cfg.h app_hooks.c os_cfg.h
  group Arduino/SD/src
    Arduino/SD/src/: File.cpp README.txt SD.cpp SD.h
  group Arduino/SD/src/utility
    Arduino/SD/src/utility/: FatStructs.h Sd2Card.cpp Sd2Card.h SdFat.h SdFatmainpage.h SdFile.cpp SdInfo.h SdVolume.cpp
  group Bitmaps
    Bitmaps/: play.bmp play_bmp.h stop.bmp stop_bmp.h
  group BSP
    BSP/: bsp.c bsp.h bspI2c.c bspI2c.h bspLcd.c bspLcd.h bspMp3.c bspMp3.h bspSD.c bspSD.h bspSpi.c bspSpi.h bspUart.c bspUart.h datainit.c hw_init.c hw_init.h layout.icf nucleoboard.h startup.s
  group BSP/CMSIS
    BSP/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f2xx.c system_stm32f4xx.h
  group BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: misc.c misc.h stm32f4xx_conf.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_usart.c stm32f4xx_usart.h
  group GUI
    GUI/: Buttons.h InputCommands.h PlayerControl.h
  group Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR
    Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Micrium/Software/uCOS-II/Source
    Micrium/Software/uCOS-II/Source/: os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c ucos_ii.h
  group MP3data
    MP3data/: GenerateMp3Header.ps1 train_crossing.h train_crossing.mp3
  group PJDF
    PJDF/: pjdf.c pjdf.h pjdfCtrlI2C.h pjdfCtrlLcdILI9341.h pjdfCtrlMp3VS1053.h pjdfCtrlSDAdafruit.h pjdfCtrlSpi.h pjdfInternal.h pjdfInternalI2C.c pjdfInternalLcdILI9341.c pjdfInternalMp3VS1053.c pjdfInternalSDAdafruit.c pjdfInternalSPI.c
  group Util
    Util/: print.c print.h printf.c printf.h
